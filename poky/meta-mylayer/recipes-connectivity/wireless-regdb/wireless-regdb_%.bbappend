FILES:${PN} += "${nonarch_base_libdir}/firmware/regulatory.db \
                ${nonarch_base_libdir}/firmware/regulatory.db.p7s \
                ${datadir}/wireless-regdb/regulatory.db \
                ${datadir}/wireless-regdb/regulatory.db.p7s \
                ${libdir}/firmware/regulatory.db \
                ${libdir}/firmware/regulatory.db.p7s \
               "
